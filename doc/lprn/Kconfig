## doc/lprn/Kconfig
```kconfig
#
# RTC class/drivers configuration
#

config PAXPRN_LIB
	tristate "PAX PRN Driver"
	default y
	help
	This is the PAX PRN driver.
```
